options:
  parameters:
    author: kittennbfive
    copyright: AGPLv3+
    description: simple receiver for nRF24L01(+) and similar
    generate_options: qt_gui
    id: nrf_receiver
    output_language: python
    title: nRF24L01(+)-receiver
  states: {}

blocks:
- name: demod_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,3)
    label: Demodulator Gain
    min_len: '100'
    start: '1'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2.4E9+nrf_channel*1e6
  states: {}
- name: lpf_cutoff
  id: variable
  parameters:
    value: (1800e3, 900e3, 700e3)[nrf_speed]
  states: {}
- name: lpf_tran_width
  id: variable
  parameters:
    value: (800e3,300e3,250e3)[nrf_speed]
  states: {}
- name: nrf_channel
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,1)
    label: nRF Channel
    min_len: '0'
    start: '0'
    step: '1'
    stop: '125'
    value: '2'
    widget: counter
  states: {}
- name: nrf_speed
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,0)
    label: nRF Speed
    label0: 2Mbps
    label1: 1Mbps
    label2: 250kbps
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (12e6, 6e6, 2e6)[nrf_speed]
  states: {}
- name: samples_per_bit
  id: variable_qtgui_label
  parameters:
    gui_hint: (0,2)
    label: Samples per Bit
    type: int
    value: (6,6,8)[nrf_speed]
  states: {}
- name: scope_nb_points
  id: variable
  parameters:
    value: (1024, 4096, 8192)[nrf_speed]
  states: {}
- name: thre_high
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,1)
    label: Threshold High
    min_len: '100'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: thre_low
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,0)
    label: Threshold Low
    min_len: '100'
    start: '-1'
    step: '0.05'
    stop: '0'
    value: '-0.2'
  states: {}
- name: trig_level
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0,1,3)
    label: Trigger (signal magnitude)
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: write_output
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: (4,2)
    label: Write to file/pipe
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_gain
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/fifo_grc
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: write_output
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thre_high
    init: '0'
    low: thre_low
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: lpf_tran_width
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    clock_source0: external
    freq0: frequency
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '15'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '256'
    gui_hint: (1,0,1,3)
    name: Filtered spectrum
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: yellow
    color2: blue
    color3: red
    ctrlpanel: 'True'
    gui_hint: (5,0,1,3)
    label1: magnitude
    label2: raw
    label3: final
    name: Demodulated signal
    nconnections: '3'
    size: scope_nb_points
    srate: samp_rate
    tr_level: trig_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.20'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: '2476000000'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_threshold_ff_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_uchar_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1, '2']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
